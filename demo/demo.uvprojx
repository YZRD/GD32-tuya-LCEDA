# Keil uVision project demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103RB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: .\BSP;.\APP;..\demo;.\mcu_sdk
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./: main.c bsp_system.c
    ./APP/: gd32f10x_it.c
  group BSP
    ./BSP/: bsp_led.c bsp_timer.c bsp_key.c bsp_usart.c bsp_ds18b20.c
  group MCU_SDK
    ./mcu_sdk/: mcu_api.c protocol.c system.c
software components: CMSIS:CORE 5.1.2, Device:GD32F10x_StdPeripherals:ADC 2.0.1, Device:GD32F10x_StdPeripherals:BKP 2.0.1, Device:GD32F10x_StdPeripherals:CAN 2.0.1, Device:GD32F10x_StdPeripherals:CRC 2.0.1, Device:GD32F10x_StdPeripherals:DAC 2.0.1, Device:GD32F10x_StdPeripherals:DBG 2.0.1, Device:GD32F10x_StdPeripherals:DMA 2.0.1, Device:GD32F10x_StdPeripherals:ENET 2.0.1, Device:GD32F10x_StdPeripherals:EXMC 2.0.1, Device:GD32F10x_StdPeripherals:EXTI 2.0.1, Device:GD32F10x_StdPeripherals:FMC 2.0.1, Device:GD32F10x_StdPeripherals:FWDGT 2.0.1, Device:GD32F10x_StdPeripherals:GPIO 2.0.1, Device:GD32F10x_StdPeripherals:I2C 2.0.1, Device:GD32F10x_StdPeripherals:MISC 2.0.1, Device:GD32F10x_StdPeripherals:PMU 2.0.1, Device:GD32F10x_StdPeripherals:RCU 2.0.1, Device:GD32F10x_StdPeripherals:RTC 2.0.1, Device:GD32F10x_StdPeripherals:SDIO 2.0.1, Device:GD32F10x_StdPeripherals:SPI_I2S 2.0.1, Device:GD32F10x_StdPeripherals:TIMER 2.0.1, Device:GD32F10x_StdPeripherals:USART 2.0.1, Device:GD32F10x_StdPeripherals:WWDGT 2.0.1, Device:GD32F10x_libopt 2.0.1, Device:Startup 2.0.1
